# Keil uVision project lcd4bit.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: lcd4bit +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c lcd.c lcd.h uart.c uart.h delay.c delay.h i2c.c ds1307.c i2c.h ds1307.h
